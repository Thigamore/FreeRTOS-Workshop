## part_3/main/Kconfig
```kconfig
menu "workshop project options"

    config WORKSHOP_DEBUG
        bool "Set whether the workshop code should be in debug or not"
        default y

endmenu
```
